# Keil uVision project ITL01.uvprojx, settings and files
target Traget (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ITL01_V9999-A +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\Core;..\Lib_code\SysLib\inc;..\Lib_code\SysHard\inc;..\Lib_code\App;..\User\Driver\USART;..\User;..\User\Key;..\User\Power;..\User\Backlight;..\User\LCD;..\User\Air;..\User\ADC;..\User\RS485;..\User\CRC;..\User\Conifig;..\User\SI4432
  memory RVCT4: ROM 0x8000800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
  group SysLib
    ../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c FlashSizeFlag.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
    ../User/CRC/: CRC16.c
  group Drive
    ../User/LCD/: HT1621.C LCD_Show.c
    ../User/Key/: KeyPort.c
    ../User/Backlight/: Backlight.c
    ../User/ADC/: adc.c
    ../User/RS485/: Polling.c
    ../User/Conifig/: config.c
  group Unit
    ../User/Air/: DeviceRelate.c AirUnit.c AirCondition.c
    ../User/Key/: KeyUnit.c
  group Attr
    ../User/Air/: AirAttr.c
  group Reame
    ../: Readme.txt
