# Keil uVision project ITL01.uvprojx, settings and files
target Traget (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ITL01_APP_V30000 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\Core;..\Lib_code\SysLib\inc;..\Lib_code\SysHard\inc;..\Lib_code\App;..\User\Driver\USART;..\User;..\User\Key;..\User\Power;..\User\Backlight;..\User\LCD;..\User\Air;..\User\ADC;..\User\RS485;..\User\CRC;..\User\Conifig;..\User\SI4432
  memory RVCT4: ROM 0x8006400 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
  group SysLib
    ../Lib_code/SysLib/: BestFu_STM32F10X_10200.lib
  group SysHard
    ../Lib_code/SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
  group APP
    ../Lib_code/App/: main.c UnitCfg.c
    ../User/CRC/: CRC16.c
  group Drive
    ../User/LCD/: HT1621.C LCD_Show.c
    ../User/Key/: KeyPort.c
    ../User/Backlight/: Backlight.c
    ../User/ADC/: adc.c
    ../User/RS485/: Polling.c
    ../User/Conifig/: config.c
  group Unit
    ../User/Air/: DeviceRelate.c AirUnit.c AirCondition.c
    ../User/Key/: KeyUnit.c
  group Attr
    ../User/Air/: AirAttr.c
  group Reame
    ../: Readme.txt
